# Keil uVision project Project.uvproj, settings and files
target STM32373C-EVAL (ARM-ADS)
  device: STM32F373VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32373C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F37X,USE_STM32373C_EVAL,
  c include: .\..\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include;.\..\..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc;.\..\..\..\..\Libraries\STM32F37x_I2C_CPAL_Driver\inc;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\STM32373C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./../src/: system_stm32f30x.c system_stm32f37x.c
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
    ./../../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/arm/: startup_stm32f37x.s
  group StdPeriph_Driver
    ./../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
    ./../../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
  group STM32_EVAL
    ./../../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
    ./../../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c
  group User
    ./../src/: main.c stm32f37x_it.c
    ./../../src/: stm32f30x_it.c
target STM32303C-EVAL (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: STM32303C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,USE_STM32303C_EVAL,
  c include: .\..\inc;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;.\..\..\..\..\Libraries\STM32F30x_I2C_CPAL_Driver\inc;.\..\..\..\..\Utilities\STM32_EVAL;.\..\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\..\Utilities\STM32_EVAL\STM32303C_EVAL;
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
